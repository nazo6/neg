# Repository nazo6/neg

File README.md:

# neg

> [!WARNING]
>
> negは現在開発中です。動作の保証は一切ありません。

negはKeyballにインスパイアされたトラックボール搭載の分割キーボードです。

## 特長

negは消費電力を可能な限り抑えて無線に対応しながらも機能面で妥協せずにLEDやディスプレイなどの高度な機能を使用できるようにすることを目標として開発中です。

### 主な特徴

- nrf52840搭載ProMicro互換ボードのnice!nanoを使用
- 高精度かつ低消費電力なPAW3395マウスセンサーを搭載
- EVQWGD001 水平ロータリーエンコーダまたはEC12ロータリーエンコーダを搭載可能
- SSD1306 OLEDディスプレイを搭載可能
- SK6812MINI-E RGB LEDを搭載可能
- 最低1.2Vから動作し単三電池、14500電池、LiPo電池またはUSBからの給電が可能
- 14500電池、LiPo電池の充電が可能
- 一部カラムスタッカード配列を採用

### 主じゃない特徴

- LEDへの電力供給にスイッチを付けることでLEDの待機電力消費を防止可能(SK6812MINI-Eは待機時でも一つあたり1mAほどの電力消費があります。)
- さらにLEDの電力供給部にはMOSFETを搭載しており、ソフトウエアからLEDのON/OFFを操作可能
- トラックボール基盤部はなるべくKeyballと互換性を持つように設計されており、Keyballのトラックボール基盤及びトラックボールケースが使用可能(要検証)
- TRRSケーブルによる有線左右間通信が可能(全二重通信を採用しており、TRSケーブルは使用できません。)
- シフトレジスタの74HC595を用いて通常のマトリックスが使用可能。これによりゴーストの軽減やより消費電力を抑えたスリープ機能の実装などが期待できます。

### マイコンについて

negではnice!nanoというボードを採用していますが、これには技適が通っていないという重大な問題があります。BLE
Micro Proとの互換性について検証中です。

## 必要部品

> [!NOTE]
>
> PCB上にある部品のうち、必要部品に無い物は全てPCBAではんだ付けすることを想定しています。

### メインPCB関連

- 左右共通

| 部品                                        | 点数(左+右) | 想定部品           | 説明                                       |
| ------------------------------------------- | ----------- | ------------------ | ------------------------------------------ |
| nice!nano                                   | 1+1         | nice!nano          | BLE Micro Pro、ProMicro RP2040にも対応予定 |
| ピンヘッダ(13ピン,短タイプ)                 | 2+2         |                    | マイコンにはんだ付け                       |
| ピンソケット(13ピン,短タイプ)               | 2+2         |                    | マイコン固定用                             |
| MXスイッチ用ソケット                        | 30+27       | Kailh CPG151101S11 |                                            |
| Chocスイッチ用ソケット                      | 3+2         | Kailh CPG135001S30 | 親指キー用                                 |
| TRRSジャック                                | 1+1         | MJ-4PP-9           |                                            |
| タクトスイッチ                              | 1+1         | TVBP06-B043CB-B    | リセットボタン                             |
| スライドスイッチ                            | 2+2         | SS-12D00G3         | 電源切り替え、LED電源切り替え用            |
| LiPo電池コネクタ                            | 1+1         | JST_PH_S2B         |                                            |
| 単三バッテリーホルダー                      | 1+1         | BH-311-1P24        |                                            |
| (オプション) ピンソケット(3ピン,短タイプ)   | 1+1         |                    | nice!nanoの追加3ピンを使用する場合必要     |
| (オプション) OLEDディスプレイ               | 1+1         | SSD1306            |                                            |
| (オプション) ピンヘッダ(4ピン)              | 1+1         |                    | OLED用。大抵の場合SSD1306に付いてくる      |
| (オプション) ピンソケット(4ピン,通常の長さ) | 1+1         | FH-1x4SG/RH        | OLEDディスプレイ差し込み用                 |
| (オプション) RGB LED                        | 33+29       | SK6812MINI-E       | LEDを追加する場合必要                      |

- 左側(非トラックボール側)のみ

| 部品              | 点数 | 想定部品 | 説明 |
| ----------------- | ---- | -------- | ---- |
| メインPCB基板(左) | 1    |          |      |

- 右側(トラックボール側)のみ

| 部品                         | 点数 | 想定部品  | 説明                                                                                            |
| ---------------------------- | ---- | --------- | ----------------------------------------------------------------------------------------------- |
| メインPCB基板(右)            | 1    |           |                                                                                                 |
| エンコーダまたはchocソケット | 1    |           | 親指最左キー部分にはEC12ロータリーエンコーダ、EVQWGD001、chocソケットのいずれかを取り付けられる |
| 7ピンL字コンスルー           | 1    | XA-3-2-7P |                                                                                                 |

### トラックボール関連

| 部品                     | 点数 | 想定部品 | 説明                   |
| ------------------------ | ---- | -------- | ---------------------- |
| 25mmトラックボール       | 1    |          |                        |
| 25mmトラックボールケース | 1    |          |                        |
| トラックボール基板       | 1    |          | 全ての部品をPCBAで実装 |

### その他

| 部品           | 点数 | 想定部品 | 説明 |
| -------------- | ---- | -------- | ---- |
| トッププレート | 2    | -        |      |
| ボトムプレート | 2    | -        |      |
| M2ねじ         |      | -        |      |
| M2スペーサー   |      | -        |      |

## 組み立て

TODO

### ジャンパについて

回路(の主に電源周り)について様々なパターンを検証するために多数のジャンパを設けています。それぞれのジャンパの説明は以下のようになります。

> [!IMPORTANT]
>
> - ある機能に対して複数のジャンパが指定されている場合、それらのジャンパ全てを接続することにより機能が有効になります。
> - 機能を切り替えるジャンパ(昇圧するかしないかなど)は排他です。必ず適切なジャンパのみをはんだ付けしてください。適切に機能しなくなったり、故障する可能性があります。

#### 電源系

- JP1:
  このジャンパを接続することにより電源回路への充電電流を防ぐダイオードを無効化し、充電を有効化します。有効化する際は必ず以下の注意事項を守ってください。

> [!CAUTION]
>
> このジャンパを接続していいのは以下の条件を全て満たしているときのみです。
>
> - 接続しているのが充電池であり、さらにそれはLiPo電池かLi-ion電池である(ニッケル水素充電池は不可)。
> - JP2かJP3の**どちらか一方のみ**を有効化しており、更に昇圧回路(JP4,JP5)を有効化していない。
> - 使用しているマイコンが適切な充電機能を有している
> - バッテリーに保護回路が組み込まれている
>
> これらの条件に違反するとバッテリーが発火したり爆発するおそれがあります。

- JP2: LiPoコネクタを有効化します。
- JP3:
  電池ホルダーとマイコンのBATピンを直結します。14500電池を入れる場合に使用します。
- JP4,JP5:
  電池ホルダーからの電源を3.3Vに昇圧します。単三電池を入れる場合に使用します。

#### キースキャン

- JP6:
  キーマトリックスのCOL0とROW3を接続します。ソフトウェアで左右を判定するのに用いることを想定しています。

#### TRRS

- JP7,8: TRRSジャックを有効化します。通常は常にこれを接続してください。
- JP9,10:
  こちらもTRRSジャックを有効化しますが、通信の極性を反転させます。RP2040でUARTを使用するテストのためのもので通常は使用する必要はありません。

#### LED

- JP11,JP12: **LED制御信号の**5V昇圧回路を無効にします。
- JP13: **LED制御信号の**5V昇圧回路を有効にします。
- JP14:
  **LED電源の**5V昇圧回路を無効にします。SK6812MINI-Eは仕様上3.3Vでは動作しないため5Vへの昇圧回路を設けていますが、実際にはそれよりも低い電圧で動作するため、動作を切り替えられるようにしています。
- JP15,JP16: **LED電源の**5V昇圧回路を有効にします。

> [!IMPORTANT]
>
> 制御信号と電源の電圧を揃えるようにしてください。
> つまり、LEDの5V昇圧を有効にする場合は「JP13,JP15,JP16」、無効にする場合は「JP11,JP12,JP14」を接続します。

> [!NOTE]
>
> 5V昇圧有効時と無効時ではLED電源切り替えスイッチの極性が反転します。

## Credits

### Kicad footprints

- Coilcraft-XFL4015:
  https://github.com/langestefan/KicadUserLib/blob/4d527574816f844b78317e347f8b6275e13600b5/user-footprints/archived/Coilcraft-XFL4015.pretty/Coilcraft-XFL4015.kicad_mod
- PAW3395: https://github.com/ufan/paw3395_pmw3361_breakout

### Kicad symbols

- SN74LVC4245A:
  https://github.com/adamgreig/agg-kicad/blob/447d20446f988afb3f98268279327dad41de4532/lib/ic/logic/sn74lvc4245a.kicad_sym

## KiCad design negL/pcb_L/pcb_L.kicad_pcb

Parts:
BT1: BH-311-1P24; BatteryHolder_Keystone_2460_1xAA
BT2: JST_PH_S2B; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
C1: GRM155R60J106ME11D; C_0402_1005Metric
C2: CL10C220JB8NNNC; C_0603_1608Metric
C3, C4: CL10A226MP8NUNE; C_0603_1608Metric
CH1, CH2, CH3: choc_v1_SW_HS; SW_choc_v1_HS_CPG135001S30_1u
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34: 1N4148W; D_SOD-123
J1: MJ-4PP-9; CON_MJ-4PP-9
J2: FH-1x4SG/RH; PinSocket_1x04_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16: SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L1: XFL4015-471MEB; L_Coilcraft_XxL4020
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32: MX_SK6812MINI-E; LED_MX_6028R
MT1, MT2, MT3, MT4, MT5, MT6, MT7, MT8, MT9, MT10, MT11, MT12: MountingHole; M2_SPACER
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29: MX_SW_HS; SW_MX_HS_CPG151101S11_1u
Q1: DMN1008UFDF-7; Diodes_UDFN2020-6_Type-F
Q2: DMP1022UFDF-7; Diodes_UDFN2020-6_Type-F
R1: CRCW0402316KFKED; R_0402_1005Metric
R2: CRCW0402100KFKED; R_0402_1005Metric
R3: 0603WAF1004T5E; R_0603_1608Metric
R4, R5, R6, R7: 0603WAF4701T5E; R_0603_1608Metric
SW1: TVBP06-B043CB-B; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
SW2: EVQWGD001_EC12; choc_encoder
SW3, SW4: SS-12D00G3
U1: nice_nano; promicro_nrf
U2: TPS61021ADSGR; S-PWSON-N8
U3: LM66100DCKR; SOT-363_SC-70-6
U4: 74HC595D,118; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
BAT+: JP2.1 (A), JP3.1 (A), JP5.2 (B), SW3.1 (A), U1.13 (BAT+)
BAT-: JP1.1 (A), U1.28 (GND), U3.1 (VIN)
COL0: JP6.1 (A), SW2.S1, U4.15 (QA)
COL1: CH1.1, MX19.1, U4.1 (QB)
COL2: CH2.1, MX1.1, MX7.1, MX13.1, MX20.1, U4.2 (QC)
COL3: CH3.1, MX2.1, MX8.1, MX14.1, MX21.1, U4.3 (QD)
COL4: MX3.1, MX9.1, MX15.1, MX22.1, MX26.1, U4.4 (QE)
COL5: MX4.1, MX10.1, MX16.1, MX23.1, MX27.1, U4.5 (QF)
COL6: MX5.1, MX11.1, MX17.1, MX24.1, MX28.1, U4.6 (QG)
COL7: MX6.1, MX12.1, MX18.1, MX25.1, MX29.1, U4.7 (QH)
COL_NCS: U1.11 (P1.04-LF), U4.12 (RCLK)
DATA_RX: JP7.2 (B), JP10.2 (B), U1.2 (P0.08)
DATA_TX: JP8.2 (B), JP9.2 (B), U1.1 (P0.06)
DISP_SCL: J2.3, JP13.1 (A), U1.10 (P0.11)
DISP_SDA: J2.4, JP14.1 (A), U1.9 (P1.00)
ENC_A: SW2.A, U1.18 (P0.29-LF)
ENC_B: SW2.B, U1.19 (P0.02-LF)
GND: J1.R2, J2.1, LED1.4 (VSS), LED2.4 (VSS), LED3.4 (VSS), LED4.4 (VSS), LED5.4 (VSS), LED6.4 (VSS), LED7.4 (VSS), LED8.4 (VSS), LED9.4 (VSS), LED10.4 (VSS), LED11.4 (VSS), LED12.4 (VSS), LED13.4 (VSS), LED14.4 (VSS), LED15.4 (VSS), LED16.4 (VSS), LED17.4 (VSS), LED18.4 (VSS), LED19.4 (VSS), LED20.4 (VSS), LED21.4 (VSS), LED22.4 (VSS), LED23.4 (VSS), LED24.4 (VSS), LED25.4 (VSS), LED26.4 (VSS), LED27.4 (VSS), LED28.4 (VSS), LED29.4 (VSS), LED30.4 (VSS), LED31.4 (VSS), LED32.4 (VSS), R3.2, SW1.2, SW2.C, U1.3 (GND), U1.4 (GND), U1.14 (GND), U3.2 (GND), U3.5 (ST), U4.8 (GND), U4.13 (~OE)
LED: JP15.1 (A), U1.8 (P0.24)
LED_CUTOFF: R3.1, SW4.3 (C), U1.17 (P0.31-LF)
LED_VCC: LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), LED20.1 (VDD), LED21.1 (VDD), LED22.1 (VDD), LED23.1 (VDD), LED24.1 (VDD), LED25.1 (VDD), LED26.1 (VDD), LED27.1 (VDD), LED28.1 (VDD), LED29.1 (VDD), LED30.1 (VDD), LED31.1 (VDD), LED32.1 (VDD), Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D), Q2.7 (D)
MISO: U1.7 (P0.22)
MOSI: U1.6 (P0.20), U4.14 (SER)
unnamed: BT1.1 (+), JP3.2 (B), JP4.2 (B)
unnamed: BT1.2 (-), BT2.2 (-), C1.2, C3.2, C4.2, Q1.4 (S), Q1.8 (S), R2.2, SW3.3 (C), U2.1 (AGND), U2.9 (PGND)
unnamed: BT2.1 (+), JP2.2 (B)
unnamed: D1.2 (A), MX1.2
unnamed: D2.2 (A), MX2.2
unnamed: D3.2 (A), MX3.2
unnamed: D4.2 (A), MX4.2
unnamed: D5.2 (A), MX5.2
unnamed: D6.2 (A), MX6.2
unnamed: D7.2 (A), MX7.2
unnamed: D8.2 (A), MX8.2
unnamed: D9.2 (A), MX9.2
unnamed: D10.2 (A), MX10.2
unnamed: D11.2 (A), MX11.2
unnamed: D12.2 (A), MX12.2
unnamed: D13.2 (A), MX13.2
unnamed: D14.2 (A), MX14.2
unnamed: D15.2 (A), MX15.2
unnamed: D16.2 (A), MX16.2
unnamed: D17.2 (A), MX17.2
unnamed: D18.2 (A), MX18.2
unnamed: D19.2 (A), MX19.2
unnamed: D20.2 (A), MX20.2
unnamed: D21.2 (A), MX21.2
unnamed: D22.2 (A), MX22.2
unnamed: D23.2 (A), MX23.2
unnamed: D24.2 (A), MX24.2
unnamed: D25.2 (A), MX25.2
unnamed: D26.2 (A), SW2.S2
unnamed: CH1.2, D27.2 (A)
unnamed: CH2.2, D28.2 (A)
unnamed: CH3.2, D29.2 (A)
unnamed: D30.2 (A), MX26.2
unnamed: D31.2 (A), MX27.2
unnamed: D32.2 (A), MX28.2
unnamed: D33.2 (A), MX29.2
unnamed: D34.2 (A), JP6.2 (B)
unnamed: JP1.2 (B), Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D), Q1.7 (D), U3.3 (~CE), U3.6 (VOUT)
unnamed: C1.1, JP4.1 (A), L1.1, U2.5 (EN), U2.8 (VIN)
unnamed: C2.1, C3.1, C4.1, JP5.1 (A), R1.1, U2.3 (VOUT), U2.4 (VOUT)
unnamed: J1.T, JP8.1 (A), JP10.1 (A), JP12.1 (A)
unnamed: J1.R1, JP7.1 (A), JP9.1 (A), JP11.1 (A)
unnamed: JP11.2 (B), R6.2
unnamed: JP12.2 (B), R7.2
unnamed: JP13.2 (B), R4.2
unnamed: JP14.2 (B), R5.2
unnamed: JP15.2 (B), LED1.3 (DIN)
unnamed: JP16.2 (B), Q2.4 (S), Q2.8 (S)
unnamed: L1.2, U2.6 (SW), U2.7 (SW)
unnamed: LED1.2 (DOUT), LED2.3 (DIN)
unnamed: LED2.2 (DOUT), LED3.3 (DIN)
unnamed: LED3.2 (DOUT), LED4.3 (DIN)
unnamed: LED4.2 (DOUT), LED5.3 (DIN)
unnamed: LED5.2 (DOUT), LED6.3 (DIN)
unnamed: LED6.2 (DOUT), LED7.3 (DIN)
unnamed: LED7.2 (DOUT), LED8.3 (DIN)
unnamed: LED8.2 (DOUT), LED9.3 (DIN)
unnamed: LED9.2 (DOUT), LED10.3 (DIN)
unnamed: LED10.2 (DOUT), LED11.3 (DIN)
unnamed: LED11.2 (DOUT), LED12.3 (DIN)
unnamed: LED12.2 (DOUT), LED13.3 (DIN)
unnamed: LED13.2 (DOUT), LED14.3 (DIN)
unnamed: LED14.2 (DOUT), LED15.3 (DIN)
unnamed: LED15.2 (DOUT), LED16.3 (DIN)
unnamed: LED16.2 (DOUT), LED17.3 (DIN)
unnamed: LED17.2 (DOUT), LED18.3 (DIN)
unnamed: LED18.2 (DOUT), LED19.3 (DIN)
unnamed: LED19.2 (DOUT), LED20.3 (DIN)
unnamed: LED20.2 (DOUT), LED21.3 (DIN)
unnamed: LED21.2 (DOUT), LED22.3 (DIN)
unnamed: LED22.2 (DOUT), LED23.3 (DIN)
unnamed: LED23.2 (DOUT), LED24.3 (DIN)
unnamed: LED24.2 (DOUT), LED25.3 (DIN)
unnamed: LED25.2 (DOUT), LED26.3 (DIN)
unnamed: LED26.2 (DOUT), LED27.3 (DIN)
unnamed: LED27.2 (DOUT), LED28.3 (DIN)
unnamed: LED28.2 (DOUT), LED29.3 (DIN)
unnamed: LED29.2 (DOUT), LED30.3 (DIN)
unnamed: LED30.2 (DOUT), LED31.3 (DIN)
unnamed: LED31.2 (DOUT), LED32.3 (DIN)
unnamed: Q1.3 (G), SW3.2 (B)
unnamed: Q2.3 (G), SW4.2 (B)
unnamed: C2.2, R1.2, R2.1, U2.2 (FB)
RESET: SW1.1, U1.15 (RST)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.20 (P1.15-LF)
ROW1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.21 (P1.13-LF)
ROW2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.22 (P1.11-LF)
ROW3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D34.1 (K), U1.23 (P0.10-LF)
ROW4: D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), U1.24 (P0.09-LF)
SCLK: U1.5 (P0.17), U4.11 (SRCLK)
VCC: J1.S, J2.2, JP16.1 (A), R4.1, R5.1, R6.1, R7.1, SW4.1 (A), U1.16 (3V3), U4.10 (~SRCLR), U4.16 (VCC)

Notes on the sheet:
Mount
LED
TRRS
Key Matrix
OLED
MCU
Power
NOTE: BLE Micro ProではBAT+の下側が5Vピン(多分VDDH?) なのでそっちにBAT+を繋ぐ(上側は多分VDDで3.6Vまでしか受け付けない!)
Reset

Board: 2 copper layers, 168.4 x 117.4 mm, 152 parts (132 on the bottom side), 113 nets.

## KiCad design negL/ball_breakout/ball_breakout.kicad_pcb

Board: 2 copper layers, 22.0 x 25.0 mm, 19 parts (15 on the bottom side), 13 nets.

Parts:
C1: CL10A475KO8NNNC; C_0603_1608Metric
C2, C4, C5: CC0603KRX7R9BB104; C_0603_1608Metric
C3: CL10A106MA8NRNC; C_0603_1608Metric
C6, C10, C11: CL10A106KP8NNNC; C_0603_1608Metric
C7: C2012X5R1A336MTJ00E; C_0805_2012Metric
J1: XA-3-2-7P Contact; Conthrough_XA-3-2-7P_Contact
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L2: SDFL2012Q1R0KTF; L_0805_2012Metric
R1: FRC0603J5R6 TS; R_0603_1608Metric
R2: 0603WAF1002T5E; R_0603_1608Metric
R5: 0603WAF2403T5E; R_0603_1608Metric
R6: 0603WAF1103T5E; R_0603_1608Metric
U1: PAW3395
U4: SK6615C; SOT-23-5

Connections:
1V9: C5.1, C6.1, C7.1, C11.1, L2.2, R1.1, R5.1, U1.4 (VDD)
3V3: C3.1, C4.1, C10.1, J1.4, R2.1, U1.7 (VDDIO), U1.14 (NRESET), U4.1 (EN), U4.4 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, J1.3, JP2.2 (B), R6.2, U1.3 (GND), U1.8 (GNDIO), U4.2 (GND)
MISO: J1.7, R2.2, U1.12 (MISO)
MOSI: J1.6, U1.11 (MOSI)
MOTION: JP1.2 (B), U1.9 (MOTION)
NCS: J1.2, U1.13 (NCS)
unnamed: J1.5, JP1.1 (A), JP2.1 (A)
unnamed: R1.2, U1.15 (LED_P)
unnamed: C1.1, C2.1, U1.5 (VDDREG)
unnamed: R5.2, R6.1, U4.5 (FB)
unnamed: L2.1, U4.3 (SW)
SCLK: J1.1, U1.10 (SCLK)

## Commit log

2024-09-15 init
2024-09-15 Add switches
2024-09-17 ball v0.1
2024-09-20 change encoder position
2024-10-14 v0.1 rc
2024-11-05 v0.1
2024-11-05 fix(pcb/right): Fixed critical bug that power switch not working
2024-11-05 fix: update sch
2024-11-07 add L
2024-11-09 add bottom
2024-11-19 pcb-l update
2024-11-20 update pcb_L
2025-01-16 updatew
